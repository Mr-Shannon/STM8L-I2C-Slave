# IAR project Backup of Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; USE_STDPERIPH_DRIVER
  ICCSTM8.CCDiagSuppress: Pe940
  ICCSTM8.CCIncludePath2: ..\Application; ..\Library\inc; ..\Drivers
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Application
    ../Application/: main.c tools.c
  group Drivers
    ../Drivers/: i2c.c uart.c
  group Library
    ../Library/src/: stm8l15x_clk.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_itc.c stm8l15x_pwr.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim4.c stm8l15x_usart.c
